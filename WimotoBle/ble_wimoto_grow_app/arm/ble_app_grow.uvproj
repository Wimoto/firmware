# Keil uVision project ble_app_grow.uvproj, settings and files
target nrf51822_xxaa_s110 (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ble_app_grow +hex
  c flags: Optim=2 oTime=1 wLevel=2
  c define: NRF51 DEBUG_NRF_USER BLE_STACK_SUPPORT_REQD BOARD_PCA10001
  c misc: --c99
  c include: ..;..\..\..\..\..\Include;..\..\..\..\..\Include\app_common;..\..\..\..\..\Include\ble;..\..\..\..\..\Include\ble\ble_services;..\..\..\..\..\Include\ble\softdevice;..\..\..\..\..\Include\s110;..\..\..\..\..\Include\ble\device_manager;..\..\..\..\..\Include\sdk;..\..\..\..\..\Include\sd_common;..\..\..\..\..\Include;..\..\ble_wimoto_grow_app;..\..\ble_wimoto_grow_app
  memory RVCT4: ROM 0x16000 size 0x2b000
  memory RVCT9: RAM 0x20002000 size 0x2000
  group Startup Code
    ../../../../../Source/templates/arm/: arm_startup_nrf51.s
    ../../../../../Source/templates/: system_nrf51.c
  group Source Code
    ../: tmp102.c connect.c main.c isl29023.c adc_soil_mois.c square_wave.c battery.c
  group Services
    ../: ble_data_log_service.c ble_light_alarm_service.c ble_soil_alarm_service.c ble_temp_alarm_service.c ble_dis.c ble_device_mgmt_service.c
    ../../../../../Source/ble/ble_services/: ble_bas.c
  group Libraries
    ../../../../../Source/ble/: ble_advdata.c ble_conn_params.c ble_radio_notification.c ble_error_log.c ble_debug_assert_handler.c
    ../../../../../Source/ble/ble_services/: ble_srv_common.c
    ../../../../../Source/app_common/: app_timer.c app_button.c app_gpiote.c pstorage.c
    ../: twi_hw_master.c
    ../../../../../Source/nrf_delay/: nrf_delay.c
    ../../../../../Source/ble/device_manager/: device_manager_peripheral.c
    ../../../../../Source/sd_common/: softdevice_handler.c
target nrf51822_xxab_s110 (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic
  cpu: as above
  output: ble_app_proximity +hex
  c flags: Optim=4 oTime=1 wLevel=2
  c define: NRF51 DEBUG_NRF_USER
  c misc: --c99
  c include: ..;..\..\..\..\..\Include;..\..\..\..\..\Include\app_common;..\..\..\..\..\Include\ble;..\..\..\..\..\Include\ble\ble_services;..\..\..\..\..\Include\ble\softdevice
  memory RVCT4: ROM 0x14000 size 0xb000
  memory RVCT9: RAM 0x20002000 size 0x2000
